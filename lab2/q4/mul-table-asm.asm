ORG 0000H

COUNTER EQU 60H
TEMP EQU 50H

MOV 20H, #03FH
MOV 21H, #006H
MOV 22H, #05BH
MOV 23H, #04FH
MOV 24H, #066H
MOV 25H, #06DH
MOV 26H, #07DH
MOV 27H, #007H
MOV 28H, #07FH
MOV 29H, #06FH

MOV A, #0AH
LCALL GENERATE_MUL_TABLE

REPEAT:
MOV R1, #040H
MOV COUNTER, #0AH
NEXT_NUMBER:
MOV A, @R1
MOV TEMP, R1
LCALL DISPLAY_NUMBER
MOV R1, TEMP
INC R1
DJNZ COUNTER, NEXT_NUMBER

JMP REPEAT

GENERATE_MUL_TABLE:
MOV R1, #049H
MOV R2, #0AH
MOV TEMP, A

NEXT_VALUE:
MOV B, R2
MUL AB
MOV @R1, A
DEC R1
MOV A, TEMP
DJNZ R2, NEXT_VALUE
RET


DISPLAY_NUMBER:
MOV R3, A
MOV R1, #30H
LCALL EXTRACT_DIGITS
MOV A, R4
MOV R5, A

MOV R7, #0FFH
INNER:
MOV R1, #30H
MOV R2, #08H

NEXT_DIGIT:
MOV R0, #20H

MOV A, @R1
ADD A, R0
MOV R0, A
INC R1

MOV P2, #0
MOV P0, @R0
MOV P2, R2

LCALL DELAY

MOV A, R2
RR A
MOV R2, A

DJNZ R4, NEXT_DIGIT
MOV A, R5
MOV R4, A

DJNZ R7, INNER

MOV A, R3
RET


EXTRACT_DIGITS:
MOV R4, #0H

EXTRACT_NEXT_DIGIT:
MOV B, #0AH
DIV AB

MOV @R1, B
INC R1
INC R4

JNZ EXTRACT_NEXT_DIGIT
RET


DELAY:
MOV R6, #0FFH
AGAIN:
DJNZ R6, AGAIN
RET

END