ORG 0000H

MOV 60H, #0A5H
MOV 61H, #0FDH
MOV 62H, #067H
MOV 63H, #042H
MOV 64H, #0DFH
MOV 65H, #09AH
MOV 66H, #084H
MOV 67H, #01BH
MOV 68H, #0C7H
MOV 69H, #031H

MOV R0, #060H
MOV R2, #00AH
LCALL SORT_ASC

DISPLAY_ASC:
MOV R0, #060H
MOV R2, #00AH
NEXT_ASC:
MOV A, @R0
MOV P0, A
INC R0
MOV R5, #010H
LCALL DELAY
DJNZ R2, NEXT_ASC

MOV R0, #060H
MOV R2, #00AH
LCALL SORT_DESC

MOV R3, #020H
LCALL DELAY

DISPLAY_DESC:
MOV R0, #060H
MOV R2, #00AH
NEXT_DESC:
MOV A, @R0
MOV P0, A
INC R0
MOV R5, #010H
LCALL DELAY
DJNZ R2, NEXT_DESC

AGAIN:
JMP AGAIN


SORT_ASC:
DEC R2
OUTER:
MOV A, R0
MOV R1, A
INC R1

MOV A, R2
MOV R3, A

INNER:
MOV A, @R1
SUBB A, @R0
JNC DO_NOTHING

SWAP_TWO:
MOV A, @R1
MOV 40H, @R0
MOV @R1, 40H
MOV @R0, A

DO_NOTHING:
INC R1
DJNZ R3, INNER
INC R0
DJNZ R2, OUTER
RET


SORT_DESC:
DEC R2
OUTER_DESC:
MOV A, R0
MOV R1, A
INC R1

MOV A, R2
MOV R3, A

INNER_DESC:
MOV A, @R1
SUBB A, @R0
JC DO_NOTHING_DESC

SWAP_TWO_DESC:
MOV A, @R1
MOV 40H, @R0
MOV @R1, 40H
MOV @R0, A

DO_NOTHING_DESC:
INC R1
DJNZ R3, INNER_DESC
INC R0
DJNZ R2, OUTER_DESC
RET
DELAY: 	MOV R7, #255
HERE1: 	MOV R6, #255
HERE2: 	MOV R5, #255
HERE3: 	DJNZ R5, HERE3
		DJNZ R6, HERE3
		DJNZ R7, HERE3
		RET
		
		END

