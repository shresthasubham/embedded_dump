ORG 00H
;to make the signal correct no loops are used
MAIN:
SETB P0.0 
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
SJMP MAIN

DELAY_10MS:
MOV TMOD, #10H
MOV TH1, #0DCH 
MOV TL1, #000H
SETB TR1
AGAIN: JNB TF1, AGAIN
	CLR TR1
	CLR TF1
RET

END