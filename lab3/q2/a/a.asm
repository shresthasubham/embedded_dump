ORG 00H
;to make the signal correct no loops are used
MAIN:
SETB P0.0 
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
CPL P0.0
LCALL DELAY_10MS
SJMP MAIN

DELAY_10MS:
MOV TMOD, #00H
MOV TH0, #070H 
MOV TL0, #000H
SETB TR0
AGAIN1_5MS: JNB TF0, AGAIN1_5MS
	CLR TR0
	CLR TF0

MOV TH0, #070H 
MOV TL0, #000H
SETB TR0
AGAIN2_5MS: JNB TF0, AGAIN2_5MS
	CLR TR0
	CLR TF0
RET


END