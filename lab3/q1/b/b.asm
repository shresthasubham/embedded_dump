ORG 00H

MAIN:
SETB P2.0
LCALL DELAY_3MS
CLR P2.0
LCALL DELAY_6MS 
LCALL DELAY_6MS
SJMP MAIN

DELAY_3MS:
MOV TMOD, #10H
MOV TH1, #0F5H 
MOV TL1, #043H
SETB TR1
AGAIN_3MS: JNB TF1, AGAIN_3MS
	CLR TR1
	CLR TF1
RET

DELAY_6MS:
MOV TMOD, #10H
MOV TH1, #0EAH 
MOV TL1, #056H
SETB TR1
AGAIN_6MS: JNB TF1, AGAIN_6MS
	CLR TR1
	CLR TF1
RET

END